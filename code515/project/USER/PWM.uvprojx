# Keil uVision project PWM.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: PWM +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\PWM;..\HARDWARE\KEY;..\HARDWARE\READ;..\HARDWARE\GPIO;..\HARDWARE\TIMER;..\HARDWARE\AI;..\HARDWARE\I2C;..\HARDWARE\MPU6050;..\HARDWARE\OLED;..\HARDWARE\ENCODER;..\HARDWARE\BUZZER
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: stm32f10x_it.c main.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/READ/: read.c
    ../HARDWARE/GPIO/: gpio.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/AI/: ai.c
    ../HARDWARE/I2C/: i2c.c
    ../HARDWARE/MPU6050/: mpu6050.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/ENCODER/: encoder.c
    ../HARDWARE/BUZZER/: buzzer.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_tim.c stm32f10x_exti.c stm32f10x_i2c.c
